SYSTEMD_AUTO_ENABLE_${PN} = "enable"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
